# Repository silver-sat/Radio_Board (continued)

## KiCad design SilverSat_Comms.kicad_pcb (continued)

Parts:
C43, C47: 0.1u; C_0603_1608Metric; Manufacturer_Part_Number 06031C104K4Z2A; Mouser Part Number 581-06031C104K4Z2A
C44, C46: 1u; C_0805_2012Metric; Manufacturer_Part_Number 08053C105K4Z2A; Mouser Part Number 581-08053C105K4Z2A
C45: 2200p; C_0603_1608Metric; MPN GCM1885C1H222FA16D
R21, R27: 110k; R_0603_1608Metric; MPN ERJ-H3EF1103V
R22: 7.15k; R_0603_1608Metric; MPN ERJ-3EKF7151V
R23: 26.1k; R_0603_1608Metric; MPN ERJ-PB3D2612V
R24: 124k; R_0603_1608Metric; MPN ERJ-3EKF1243V
R25: 53.6k; R_0603_1608Metric; MPN ERJ-3EKF5362V
R26: 10k; R_0603_1608Metric; Manufacturer_Part_Number CRCW040210K0DHEDP
R28: 31.6k; R_0603_1608Metric; MPN ERJ-3EKF3162V
R29: 10k; R_0603_1608Metric; MPN ERJ-3RBD1002V
U5: TVS1800DRVR; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm; MPN TVS1800DRVR; Mouser Part Number 595-TVS1800DRVR
U6: TPS25940LQRVCRQ1; QFN-20-1EP_3x4mm_P0.5mm_EP1.65x2.65mm_ThermalVias; Manufacturer_Part_Number TPS25940LQRVCRQ1; Mouser Part Number 595-TPS25940LQRVCRQ1

Connections:
+5V: C43.1, C44.1, R21.1, U5.4 (IN), U5.5 (IN), U5.6 (IN), U6.9 (IN_1), U6.10 (IN_2), U6.11 (IN_3), U6.12 (IN_4), U6.13 (IN_5); also elsewhere on the board
/3V3_Protected: R26.1, R29.1; also elsewhere on the board
/5V_Current: R25.1, U6.19 (IMON); also elsewhere on the board
/OC5V: R29.2, U6.20 (~FLT); also elsewhere on the board
/eFuse5V/5V_LUP: C46.1, C47.1, R27.1, U6.4 (OUT_1), U6.5 (OUT_2), U6.6 (OUT_3), U6.7 (OUT_4), U6.8 (OUT_5); also elsewhere on the board
/eFuse5V/Ilim: R24.1, U6.17 (ILIM)
/eFuse5V/PGth: R27.2, R28.1, U6.3 (PGTH)
/eFuse5V/Pgood: R26.2, U6.2 (PGOOD)
/eFuse5V/~RST: R21.2, R22.1, U6.14 (EN/UVLO)
GND: C43.2, C44.2, C45.2, C46.2, C47.2, R23.2, R24.2, R25.2, R28.2, U5.1 (GND), U5.2 (GND), U5.3 (GND), U5.7 (GND), U6.16 (GND), U6.21 (EP); also elsewhere on the board
unnamed: C45.1, U6.18 (DVDT)
unnamed: R22.2, R23.1, U6.15 (OVP)

Notes on the sheet:
this version latches on overcurrent use TPS25940-Q1 for Auto-retry
Design assumes: Vcc(max) = 5.15V (from EPS datasheet) Undervoltage = 4V Overvoltage = 5.5V Load capacitance = 10uF "Load at startup" = 120 ohms Max continuouse current = 0.6A (TBD once we drive amp) Pgood = 4.5V Current limit (trip) = 0.72A
SEE LAYOUT GUIDELINES IN DATASHEET

Parts:
C39, C41, C42: 0.1u; C_0603_1608Metric; MPN 06031C104K4Z2A
C40: 10u; C_1210_3225Metric; Part_Number 12103C106K4Z2A
L12: Ferrite Bead; L_0603_1608Metric; Part_Number BLM18SP102SH1D
R18, R19, R20: 10k; R_0603_1608Metric; Part_Number ERJ-3EKF1002V
U4: FPF2004; SOT-353_SC-70-5; MPN FPF2004

Connections:
+3V3: C39.1, L12.1; also elsewhere on the board
/eFuse3V3.sch/3V3_IN_FILT: C40.1, L12.2, R18.1, R19.1, U4.5 (VIN)
/eFuse3V3.sch/3V3_P: C41.1, C42.1, R20.1, U4.1 (VOUT); also elsewhere on the board
GND: C39.2, C40.2, C41.2, C42.2, R20.2, U4.2 (GND); also elsewhere on the board
unnamed: R19.2, U4.3 (FLAGB)
unnamed: R18.2, U4.4 (ON)

Notes on the sheet:
Vabs_max for FPF2004 is 6V Current limit for FPF2004 is 100mA

Parts:
C64, C65: 10u; C_1210_3225Metric; Part_Number 12103C106K4Z2A
C66: DNI; C_0603_1608Metric; not fitted
R40: 10k; R_0603_1608Metric; MPN ERJ-3RBD1002V; Mouser Part Number 667-ERJ-PB3B1202V
TP9: TestPoint; TestPoint_Pad_D1.0mm
U12: TPS22965NTDSGRQ1; DFN-8-1EP_2.1x2.1mm_P0.5mmx0.25mm_EP0.8x1.6mm; MPN TPS22965NTDSGRQ1

Connections:
/PAENABLE: R40.2, TP9.1, U12.3 (ON); also elsewhere on the board
/PAPowerSwitch/Vin: C64.1, C65.1, U12.1 (Vin), U12.2 (Vin), U12.4 (Vbias); also elsewhere on the board
/PAPowerSwitch/Vout: U12.7 (Vout), U12.8 (Vout); also elsewhere on the board
GND: C64.2, C65.2, C66.1, R40.1, U12.5 (GND); also elsewhere on the board
unnamed: C66.2, U12.6 (CT)

Notes on the sheet:
Cap on Vin should be 10x capacitance on Vout NOTE: this can affect the eFuse design!
Pull down to ensure PA is off if processor output is tri-stated
Sets slew-rate

Schematic: serial_driver.kicad_sch

Parts:
C59, C60: 0.1u; C_0603_1608Metric; MPN 06031C104K4Z2A
R33: 10k; R_0603_1608Metric; MPN ERJ-3RBD1002V
R34: 453; R_0603_1608Metric; MPN ERJ-3EKF4530V
U9: SN65HVD70D; SOIC-14_3.9x8.7mm_P1.27mm; MPN SN65HVD70D

Connections:
/3V3_Protected: C59.2, U9.13 (Vcc), U9.14 (Vcc); also elsewhere on the board
/EN0: U9.4 (DE); also elsewhere on the board
/RADIO_RXD+: R34.1, U9.12 (A); also elsewhere on the board
/RADIO_RXD-: C60.2, U9.11 (B); also elsewhere on the board
/RADIO_TXD+: U9.9 (Y); also elsewhere on the board
/RADIO_TXD-: U9.10 (Z); also elsewhere on the board
/RXD1: U9.2 (R); also elsewhere on the board
/TXD1: U9.5 (D); also elsewhere on the board
GND: C59.1, R33.1, U9.6 (GND), U9.7 (GND); also elsewhere on the board
unnamed: C60.1, R34.2
unnamed: R33.2, U9.3 (RE)

Parts of its further copies:
C61, C62: 0.1u; C_0603_1608Metric; MPN 06031C104K4Z2A
R35: 10k; R_0603_1608Metric; MPN ERJ-3RBD1002V
R36: 453; R_0603_1608Metric; MPN ERJ-3EKF4530V
U10: SN65HVD70D; SOIC-14_3.9x8.7mm_P1.27mm; MPN SN65HVD70D

Connections of its further copies:
/3V3_Protected: C61.2, U10.13 (Vcc), U10.14 (Vcc); also elsewhere on the board
/EN1: U10.4 (DE); also elsewhere on the board
/PAYLOAD_RXD+: R36.1, U10.12 (A); also elsewhere on the board
/PAYLOAD_RXD-: C62.2, U10.11 (B); also elsewhere on the board
/PAYLOAD_TXD+: U10.9 (Y); also elsewhere on the board
/PAYLOAD_TXD-: U10.10 (Z); also elsewhere on the board
/RXD0: U10.2 (R); also elsewhere on the board
/TXD0: U10.5 (D); also elsewhere on the board
GND: C61.1, R35.1, U10.6 (GND), U10.7 (GND); also elsewhere on the board
unnamed: C62.1, R36.2
unnamed: R35.2, U10.3 (RE)

Schematic: externalwatchdog.kicad_sch

Parts:
C63: 0.1u; C_0603_1608Metric; MPN 06031C104K4Z2A
U11: TPS3813K33QDBVRQ1; SOT-23-6; MPN TPS3813K33QDBVRQ1

Connections:
/3V3_Protected: C63.1, U11.3 (WDT), U11.4 (Vdd), U11.5 (WDR); also elsewhere on the board
/ExternalWatchdog/WDTICK: U11.1 (WDI); also elsewhere on the board
/~RESET: U11.6 (RESET); also elsewhere on the board
GND: C63.2, U11.2 (GND); also elsewhere on the board

Schematic: pi_net.kicad_sch, Pi Attenuator Network

Parts:
R37, R39: 130; R_0402_1005Metric; Voltage 50; MPN ERJ-PA2F1300X
R38: 44.2; R_0402_1005Metric; MPN ERJ-2RKF44R2X; Mouser Part Number 667-ERJ-2RKF44R2X

Connections:
/AX5043/Attenuator/RX: R38.2, R39.2; also elsewhere on the board
/AX5043/Attenuator/VOUT: R37.2, R38.1; also elsewhere on the board
GND: R37.1, R39.1; also elsewhere on the board

Notes on the sheet:
Attenuation (dB) 0.0 1.0 2.0 3.0 4.0 5.0 6.0 7.0 8.0 9.0 10.0 11.0 12.0 13.0 14.0 15.0 R44 (ohms) 0.0 5.8 11.6 17.6 23.8 30.4 37.4 44.8 52.8 61.6 71.2 81.7 93.2 106.1 120.3 136.1 R43 & 45 (ohms) NC 869.5 436.2 292.4 221.0 178.5 150.5 130.7 116.1 105.0 96.2 89.2 83.5 78.8 74.9 71.6 Attenuation (dB) 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

Board: 4 copper layers, 115.5 x 95.9 mm, 179 parts (0 on the bottom side), 120 nets.

File HTMLBOM.xlsx:

References | Value | MPN | Manufacturer | Quantity | Source | 68
C4, C6, C8, C9, C10, C12, C22, C39, C41, C42, C43, C47, C59, C60, C61, C62, C63 | 0.1u | 06031C104K4Z2A | AVX | 17 | Mouser | 68
C14, C17, C18, C23, C68 | 0.01u | 06033C103J4Z2A | AVX | 5 | Mouser
C5, C7, C13 | 1u | 12065C105M4Z2A | AVX | 3 | Mouser
C27, C28, C29 | 4.3p | GCM1555C1H4R3BA16D | Murata | 3 | Mouser
C30, C31, C32 | 5.6p | 04025U5R6B4T2A | AVX | 3 | Mouser
C36, C52, C53 | 6.8p | GCM1555C1H6R8BA16D | Murata | 3 | Mouser
C38, C51, C67 | 100p | GCM1555C1H101FA16J | Murata | 3 | Mouser
C40, C64, C65 | 10u | 12103C106K4Z2A | AVX | 3 | Mouser
C2, C3 | 20p | 06031A200K4T2A | AVX | 2 | Mouser
C20, C21 | 100p | 06031A101F4T2A | AVX | 2 | Mouser
C33, C34 | 5.1p | GCQ1555C1H5R1WB01D | Murata | 2 | Mouser
C44, C46 | 1u | 08053C105K4Z4A | AVX | 2 | Mouser
C55, C56 | 56p | GCM1555C1H560FA16D | Murata | 2 | Mouser
C57, C58 | 220p | GRT1555C1H221FA02D | Murata | 2 | Mouser
C1 | 0.01u | ESD31C103K4T2A-18 | AVX | 1 | Mouser
C11 | 4.7u | GRT188C81C475KE13D | Murata | 1 | Mouser
C15 | 39p | 06035A390J4T2A | AVX | 1 | Mouser
C19 | 4.7u | 12065C475K4Z2A | AVX | 1 | Digikey
C45 | 2200p | GCM1885C1H222FA16D | Murata | 1 | Mouser
C48 | 12p | 04025A120F4T2A | AVX | 1 | Mouser
C49 | 15p | GRT1555C1H150FA02D | Murata | 1 | Mouser
C50 | 2.2u | C1210C225K1RACAUTO | KEMET | 1 | Mouser
C54 | 39p | GRT1555C1H390FA02D | Murata | 1 | Mouser
R6, R7, R8, R9, R12, R13, R18, R19, R20, R26, R29, R33, R35, R40 | 10k | ERJ-3RBD1002V | Panasonic | 14 | Mouser
R2, R3, R4, R5, R14, R31, R32, R38, R44, R45 | 0 | ERJ-2GE0R00X | Panasonic | 10 | Mouser
R41, R42, R43 | 0 | ERJ-3GEY0R00V | Panasonic | 3 | Mouser
R21, R27 | 110k | ERJ-H3EF1103V | Panasonic | 2 | Mouser
R34, R36 | 453 | ERJ-3EKF4530V | Panasonic | 2 | Mouser
R1 | 1M | ERJ-PA3F1004V | Panasonic | 1 | Mouser
R10 | 931 | ERJ-PB3B9310V | Panasonic | 1 | Mouser
R11 | 330 | ERJ-H3EF3300V | Panasonic | 1 | Mouser
R15 | 12k | ERJ-3RBD123V | Panasonic | 1 | Mouser
R16 | 220 | ERJ-PB3D2200V | Panasonic | 1 | Mouser
R17 | 100 | ERJ-3RBD101V | Panasonic | 1 | Mouser
R22 | 7.15k | ERJ-3EKF7151V | Panasonic | 1 | Mouser
R23 | 26.1k | ERJ-PB3D2612V | Panasonic | 1 | Mouser
R24 | 124k | ERJ-3EKF1243V | Panasonic | 1 | Mouser
R25 | 53.6k | ERJ-3EKF5362V | Panasonic | 1 | Mouser
R28 | 31.6k | ERJ-3EKF3162V | Panasonic | 1 | Mouser
R30 | 5.0999999999999996 | ERJ-U03F5R10V | Panasonic | 1 | Mouser
L3, L4, L5 | 0.100u | 0402DC-R10XJRW | Coilcraft | 3 | Mouser
L6, L7, L8 | 43n | 0402DC-43NXGRW | Coilcraft | 3 | Mouser
L1, L12 | Ferrite Bead | BLM18SP102SH1D | Murata | 2 | Mouser
L9, L10 | 27n | 0402DC-27NXGRW | Coilcraft | 2 | Mouser
L2 | 10n | 0603DC-10NXJRW | Coilcraft | 1 | Mouser
L11 | 4.7n | 0402DC-4N7XGRW | Coilcraft | 1 | Mouser
L13 | 40n | 0402DC-39NXGRW | Coilcraft | 1 | Mouser
L14 | 4.3n | 0402DC-4N3XGRW | Coilcraft | 1 | Mouser
L15 | 47n | 0402DC-47NXGRW | Coilcraft | 1 | Mouser
L16 | 5.1n | 0402DC-5N1XGRW | Coilcraft | 1 | Mouser
D1 | LED |  |  | 1
U9, U10 | SN65HVD70D | SN65HVD70D | Texas Instruments | 2 | Mouser
U1 | USBLC6-2SC6 | USBLC6-4SC6 | ST Micro | 1 | Mouser
U2 | ATSAMD21G18A-A | ATSAMD21G18A-A | Microchip | 1 | Silversat
U3 | AX5043 | AX5043-1-TW30 | OnSemi | 1 | Mouser
U4 | FPF2004 | FPF2004 | Fairchild | 1 | Digikey
U5 | TVS1800DRV | TVS1800DRVR | Texas Instruments | 1 | Arrow
U6 | TPS25940LQRVCRQ1 | TPS25940LRVCR | Texas Instruments | 1 | Digikey
U7 | CAEL-CG2409M2 | CG2409M2-C4 | CEL | 1 | Mouser
U8 | TMP100 | TMP100NA/3K | Texas Instruments | 1 | Digikey
U11 | TPS3813-Q1_Watchdog | TPS3813K33-Q1 | Texas Instruments | 1
U12 | TPS22965NTDSGRQ1 | TPS22965NTDSGRQ1 | TI | 1 | Mouser
Y1 | CM8V-T1A-32.768KHZ-12.5PF-20PPM-TB-QA | CM8V-T1A-32.768KHZ-12.5PF-20PPM-TB-QA | Micro Crystal AG | 1 | Mouser
X1 | TG2016SMN | TG2016SMN 48.0000M-ECGNNM0 | Seiko Epson Corporation | 1 | Mouser
F1 | 300 mA | PICOASMDC012S-2 | Littelfuse | 1 | Digikey
H1, H2 | Conn_02x26_Odd_Even | HMTSW-126-22-G-D-440 | Samtec | 2 | Mouser
S1, S3 | MS353-10C_Masach_Shield | MS355-10F | Masach | 2 | Mouser
PA1 | HMC452ST89 | HMC452ST89ETR | Analog Devices | 1 | Mouser
J1 | USB_B_Micro | 105017-0001 | Molex | 1 | Mouser
J2 | Conn_Coaxial | 901-143-6RFX | Amphenol | 1 | Mouser
J3 | 53261-0471 | 53261-0471 | Molex | 1 | Mouser
J4 | 504050-0691 | 504050-0691 | Molex | 1 | Mouser
J5 | MTSW-103-06-G-D-110 | MTSW-103-06-G-D-110 | Samtec | 1 | Mouser
J6 | 77315-801-02LF | 77315-801-02LF | Amphenol | 1 | Mouser
J7 | ~ | 4048 | Adafruit | 1 | Mouser

## Code that names these connections

File Arduino_Board_Definitions/SilverSat_Radio_Board/0.1/variants/mkrwifi1010/variant.cpp (part):

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 |            |                  |        |                 |   EIC  | ADC |  AC | PTC | DAC | SERCOMx | SERCOMx |  TCCx  |  TCCx  |    COM   | AC/GLCK  |
 |            |                  |        |                 |(EXTINT)|(AIN)|(AIN)|     |     | (x/PAD) | (x/PAD) | (x/WO) | (x/WO) |          |          |
 +------------+------------------+--------+-----------------+--------+-----+-----+-----+-----+---------+---------+--------+--------+----------+----------+
 | 00         | D0               |  PA22  |                 |  *06   |     |     | X10 |     |   3/00  |   5/00  |* TC4/0 | TCC0/4 |          | GCLK_IO6 |
 | 01         | D1               |  PA23  |                 |  *07   |     |     | X11 |     |   3/01  |   5/01  |* TC4/1 | TCC0/5 | USB/SOF  | GCLK_IO7 |
 | 02         | D2               |  PA10  |                 |   10   | *18 |     | X02 |     |   0/02  |   2/02  |*TCC1/0 | TCC0/2 | I2S/SCK0 | GCLK_IO4 |
 | 03         | D3               |  PA11  |                 |   11   | *19 |     | X03 |     |   0/03  |   2/03  |*TCC1/1 | TCC0/3 | I2S/FS0  | GCLK_IO5 |
 | 04         | D4               |  PB10  |                 |  *10   |     |     |     |     |         |   4/02  |* TC5/0 | TCC0/4 | I2S/MCK1 | GCLK_IO4 |
 | 05         | D5               |  PB11  |                 |  *11   |     |     |     |     |         |   4/03  |* TC5/1 | TCC0/5 | I2S/SCK1 | GCLK_IO5 |
 | 06         | D6               |  PA20  | LED_BUILTIN     |  *04   |     |     | X08 |     |   5/02  |   3/02  |        |*TCC0/6 | I2S/SCK0 | GCLK_IO4 |
 | 07         | D7               |  PA21  |                 |  *05   |     |     | X09 |     |   5/03  |   3/03  |        |*TCC0/7 | I2S/FS0  | GCLK_IO5 |
 +------------+------------------+--------+-----------------+--------+-----+-----+-----+-----+---------+---------+--------+--------+----------+----------+
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 |            |                  |        |                 |(EXTINT)|(AIN)|(AIN)|     |     | (x/PAD) | (x/PAD) | (x/WO) | (x/WO) |          |          |
 +------------+------------------+--------+-----------------+--------+-----+-----+-----+-----+---------+---------+--------+--------+----------+----------+
 |            |       SPI        |        |                 |        |     |     |     |     |         |         |        |        |          |          |
 | 08         | MOSI             |  PA16  |                 |  *00   |     |     | X04 |     |  *1/00  |   3/00  |*TCC2/0 | TCC0/6 |          | GCLK_IO2 |
 | 09         | SCK              |  PA17  |                 |  *01   |     |     | X05 |     |  *1/01  |   3/01  | TCC2/1 | TCC0/7 |          | GCLK_IO3 |
 | 10         | MISO             |  PA19  |                 |   03   |     |     | X07 |     |  *1/03  |   3/03  |* TC3/1 | TCC0/3 | I2S/SD0  | AC/CMP1  |
 +------------+------------------+--------+-----------------+--------------------+-----+-----+---------+---------+--------+--------+----------+----------+
 |            |       Wire       |        |                 |        |     |     |     |     |         |         |        |        |          |          |
 | 11         | SDA              |  PA08  |                 |   NMI  | *16 |     | X00 |     |  *0/00  |   2/00  | TCC0/0 | TCC1/2 | I2S/SD1  |          |
 | 12         | SCL              |  PA09  |                 |   09   | *17 |     | X01 |     |  *0/01  |   2/01  | TCC0/1 | TCC1/3 | I2S/MCK0 |          |
 +------------+------------------+--------+-----------------+--------+-----+-----+-----+-----+---------+---------+--------+--------+----------+----------+
 |            |      Serial1     |        |                 |        |     |     |     |     |         |         |        |        |          |          |
 | 13         | RX               |  PB23  |                 |   07   |     |     |     |     |         |  *5/03  |        |        |          | GCLK_IO1 |
 | 14         | TX               |  PB22  |                 |   06   |     |     |     |     |         |  *5/02  |        |        |          | GCLK_IO0 |
 +------------+------------------+--------+-----------------+--------+-----+-----+-----+-----+---------+---------+--------+--------+----------+----------+
 */
                                                                                                                                               // DIPO=3 DOPO=0
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 |            |                  |        |                 |   EIC  | ADC |  AC | PTC | DAC | SERCOMx | SERCOMx |  TCCx  |  TCCx  |    COM   | AC/GLCK  |
 |            |                  |        |                 |(EXTINT)|(AIN)|(AIN)|     |     | (x/PAD) | (x/PAD) | (x/WO) | (x/WO) |          |          |
 +------------+------------------+--------+-----------------+--------+-----+-----+-----+-----+---------+---------+--------+--------+----------+----------+
 | 15         | A0 / DAC0        |  PA02  |                 |   02   | *00 |     | Y00 | OUT |         |         |        |        |          |          |
 | 16         | A1               |  PB02  |                 |  *02   | *10 |     | Y08 |     |         |   5/00  |        |        |          |          |
 | 17         | A2               |  PB03  |                 |  *03   | *11 |     | Y09 |     |         |   5/01  |        |        |          |          |
 | 18         | A3               |  PA04  |                 |   04   | *04 |  00 | Y02 |     |         |   0/00  |*TCC0/0 |        |          |          |
 | 19         | A4               |  PA05  |                 |   05   | *05 |  01 | Y03 |     |         |   0/01  |*TCC0/1 |        |          |          |
 | 20         | A5               |  PA06  |                 |   06   | *06 |  02 | Y04 |     |         |   0/02  | TCC1/0 |        |          |          |
 | 21         | A6               |  PA07  |                 |   07   | *07 |  03 | Y05 |     |         |   0/03  | TCC1/1 |        | I2S/SD0  |          |
 +------------+------------------+--------+-----------------+--------+-----+-----+-----+-----+---------+---------+--------+--------+----------+----------+
 */
  { PORTA,  2, PIO_ANALOG,  (PIN_ATTR_DIGITAL|PIN_ATTR_ANALOG /*DAC*/        ), ADC_Channel0,   NOT_ON_PWM, NOT_ON_TIMER, EXTERNAL_INT_NONE },
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 |            |                  |        |                 |(EXTINT)|(AIN)|(AIN)|     |     | (x/PAD) | (x/PAD) | (x/WO) | (x/WO) |          |          |
 +------------+------------------+--------+-----------------+--------+-----+-----+-----+-----+---------+---------+--------+--------+----------+----------+
 |            |       USB        |        |                 |        |     |     |     |     |         |         |        |        |          |          |
 | 22         |                  |  PA24  | USB N           |   12   |     |     |     |     |   3/02  |   5/02  |  TC5/0 | TCC1/2 | USB/DM   |          |
 | 23         |                  |  PA25  | USB P           |   13   |     |     |     |     |   3/03  |   5/03  |  TC5/1 | TCC1/3 | USB/DP   |          |
 | 24         |                  |  PA18  | USB ID          |   02   |     |     | X06 |     |   1/02  |   3/02  |  TC3/0 | TCC0/2 |          | AC/CMP0  |
 +------------+------------------+--------+-----------------+--------+-----+-----+-----+-----+---------+---------+--------+--------+----------+----------+
 | 25         | AREF             |  PA03  |                 |   03   |  01 |     | Y01 |     |         |         |        |        |          |          |
 +------------+------------------+--------+-----------------+--------+-----+-----+-----+-----+---------+---------+--------+--------+----------+----------+
 */
  { PORTA, 24, PIO_COM,     (PIN_ATTR_NONE                                   ), No_ADC_Channel, NOT_ON_PWM, NOT_ON_TIMER, EXTERNAL_INT_NONE }, // USB/DM
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 |            |                  |        |                 |(EXTINT)|(AIN)|(AIN)|     |     | (x/PAD) | (x/PAD) | (x/WO) | (x/WO) |          |          |
 +------------+------------------+--------+-----------------+--------+-----+-----+-----+-----+---------+---------+--------+--------+----------+----------+
 |            | WiFi SPI         |        |                 |        |     |     |     |     |         |         |        |        |          |          |
 | 26         |                  |  PA12  | NINA_MOSI       |   12   |     |     |     |     |  *2/00  |   4/00  | TCC2/0 | TCC0/6 |          | AC/CMP0  |
 | 27         |                  |  PA13  | NINA_MISO       |   13   |     |     |     |     |  *2/01  |   4/01  | TCC2/1 | TCC0/7 |          | AC/CMP1  |
 | 28         |                  |  PA14  | NINA_CS         |   14   |     |     |     |     |   2/02  |   4/02  |  TC3/0 | TCC0/4 |          | GCLK_IO0 |
 | 29         |                  |  PA15  | NINA_SCK        |   15   |     |     |     |     |  *2/03  |   4/03  |  TC3/1 | TCC0/5 |          | GCLK_IO1 |
 | 30         |                  |  PA27  | NINA_GPIO0      |  *15   |     |     |     |     |         |         |        |        |          | GCLK_IO0 |
 | 31         |                  |  PB08  | NINA_RESETN     |   08   |  02 |     | Y14 |     |         |   4/00  |  TC4/0 |        |          |          |
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
## Commit log (part)

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2022-05-25 Fields table
    There's something strange going on with how the fields table is being populated in Kicad. I found several components without the value field filled in, but if I clicked in the box, and said OK, then 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
2022-05-25 Added R & C part numbers, accidental R20 edit (fixed) Total Changes - Added part numbers to capacitors 10 to 34 - Added part numbers to resistors 14 and 18 (R16 is blank because it is DNI; R17 is bla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
2022-05-26 This is a test
    I deleted the "H" on 27nH (L11). This has caused the value field at line 1312 to be deleted (in the change view). However, it still appears to be the value of the part.
2022-05-27 updated a bunch of parts
    Adjusted some of the parts to point to the datasheet (hopefully this works!) folder.
    Made all the 0.1u parts look alike. Adjusted most (but not all!) datasheets to point to the local (in the project) datasheet.
2022-06-02 layout update
    Moved board outline to the edgecuts layer.
    Assigned 0603 footprint to resistors. Found a few more extra spaces in part values and fixed.
    Imported footprints.
2022-06-02 Fixed issues and used custom TG2016SMN TCXO
2022-06-03 Amp network note
    Added note to identify the Class E network. See this note: https://www.onsemi.com/forum/t/faq-how-to-operate-ax5043-at-27-mhz-custom-matching-networks-for-ax5043/274
2022-06-03 Moved 1 GND slightly
2022-06-06 Grammar fix on line 53
2022-06-07 Migrate ADD5043
    I made my first attempt at migrating the ADD5043-433-2-GEVK evaluation board (from the gerber) onto the radio PCB. Hopefully this worked.
    I still need to check whether all fo the footprints line up and are compatible with our part choices. I also need to integrate these changes into the final layout, but this depends on drawing the res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
2022-06-08 Removed CAL connection on AX5043
    The CAL connection is used to calibrate an offset, which we're not planning on needing. Plus, I am seeing an odd coupling path on the dev board which is causing noise on the main VCO. The datasheet r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
    So, I removed the connection and grounded the ADCs..
2022-06-10 Fixed outline error
    I fixed the outline error. This was exactly the same issue as we encountered on payload, but it's an easy fix. Just move one of the endpoints to make them coincident. You know they're lined up when t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
2022-06-10 Update AX5043 parts list & PCB Summary of changes - Replaced 0603 parts on RF lines with 0402 equivalents - Imported changes into PCB
2022-06-13 Brought out current monitor
    Brought out the current monitoring pins from the eFuses and tied them to the SAMD21
    I don't know why Kicad/Github desktop is telling me that it's got changes on other schematics, but they don't seem to be real.
2022-06-13 Design notes
    Modified the part order on the AX5043 page to drive home how the design can be analyzed. Note that all three Class-E networks are identical. Added block to identify filter parts (when selecting, note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
2022-06-20 Part number fixes Summary of Changes: - Fixed C15; C25; C26; C30; C32; R14; R43; R44; & R45 fields per tconrad26's email - Copied some “Manufacturer” field values in Symbol Fields to “Manufacturer_Na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
    Not done:
    - Change 4.7pF Capacitor part Number: Capacitor not found
2022-06-25 More moves
    Moved some AX5043 non-RF components to make room for RF shielding
2022-06-25 Add SMA part number
2022-06-27 Connect SMA & annotate Summary of changes: - Connected SMA to RF line from TX/RX switch - Re-annotated schematic in preparation for PCB import - Loaded last two changes into PCB
2022-07-08 Rearrange, reannotate, & add RF shield
2022-07-09 Power switch for PA
    Completed the schematic for the PA power switch and imported the parts to the PCB
    Made some other small tweaks to the schematic to improve readability
2022-07-09 Added additional datasheets for reference
    See description
2022-07-09 Edit RF shield again
2022-07-09 Rearrange parts
    Summary of changes
    - Rearranges some parts
    - Updated a few datasheets
    ToDo: Rearrange Q1 parts per its datasheet
2022-07-10 added notes for shield placement
    see comment
2022-07-10 Update SilverSat_Comms.kicad_pcb
    Moved the temp sensor to other side of PA and moved the entire network down
2022-07-11 updated fab drawing and placement
    Modified the placement slightly to eliminate overlapped courtyards.
    Removed all extraneous info from fab layer.
2022-07-11 Reversed pins on serial_driver_0
    Reversed the pins on the serial_driver_0 block (TX/RX) since that's the interface from Avionics
    I believe the convention is that Avionics does not cross up to this point.
2022-07-12 Update SilverSat_Comms.kicad_sch
    Added mounting holes
2022-07-13 Layout in progress Summary of changes - Moved most components on to the board - Some board layout changes
2022-07-14 Update SilverSat_Comms.kicad_pcb
    The last commit would not load, so I copied the file from tmp and I am trying to put it back manually.
2022-07-16 Remove antenna tuner
2022-07-18 Replaced last PCB file with file from backup
    Replaced PCB file with the PCB from the SilverSat_Comms-2022-07-17_183010.zip archive.
2022-07-20 Update PCB and schematic
2022-07-21 Layout and schematic changes
2022-07-23 Edited pins and added footprints on PA switch
2022-07-24 Getting closer…
2022-07-25 Small changes @tconrad26 , could you review my changes and make sure I didn't mess anything up?
2022-07-25 Imported schematic changes
    Imported schematic changes
2022-07-26 One more change
2022-07-28 First of today's changes Partial summary of changes - Connected RF traces between shields and added ground planes - Small layout changes - Tweaks in AX5043 schematic
2022-07-29 One last change Deleted unnecessary ground vias on PA1 (the RF amplifier)
2022-07-29 Fixed today's DRC errors
2022-07-30 One very unimportant change With some extra free time, I added the SilverSat logo to the silkscreen layer.
2022-08-01 Cleanup and mess-making
    Changes:
    - Cleaned up traces
    - Changed minimum width from 5 mils to 8 mils
    - Added 100pF capacitor to TX/RX line
    - Reannotated schematic and updated PCB
    Issues
2022-08-02 Add 3V3 plane
2022-08-03 Various changes 3 and cleanup Issues - Upon changing the minimum trace width to 8 mils, the DRC spotted many errors. To fix these errors, the concerning areas were relocated without much consideratio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
2022-08-03 Silkscreen updated
2022-08-04 Add board view to README
2022-08-04 RF path changes # Long description Added 100pF capacitors between RF shields All RF traces now mouse-hole through the shields (130pF per hole) Deleted Int.2 ground layer
2022-08-05 Fix DRC silkscreen warnings
2022-08-06 Update PCB
2022-08-06 Move TX/RX traces away from shield
2022-08-07 Name zones Name zones for project self-documentation Adjust zone priorities to allow for etchant-saving copper zone
    Notes
    An unconnected zone, added on all layers to save etchant, was
    added during commit development but was removed to improve
    soldering ease.
2022-08-08 Silkscreen, schematic, and draft assembly instructions
2022-08-10 Tuesday meeting changes
2022-08-10 Add issue to line 59
2022-08-10 Add and label pwoer layers
2022-08-12 Theme update
2022-08-13 BOM changes
    modified frame and cover part numbers to match
    changed all holes to no-BOM
2022-08-13 3D models
    Added missing 3D models.
2022-08-13 OCV3V3
    Modified OC3V# to eliminate 2 vias
2022-08-13 Update SilverSat_Comms.kicad_pcb
    Put back the logo footprint.
2022-08-13 Revert "Updated 3d model locations"
    This reverts commit 0f5800f6ad3e3498aff166fb09838c703b4b80c4.
2022-08-14 fixed DRC errors
    Looks like a recent part import overwrote the local footprint changes.
    I updated the Silversat Kicad library to fix the HMC452, so make sure to update
    U6 hole size is modified local (not in library). Both parts are locked now and shouldn't update without a warning. Other DRC issues resolved.
2022-08-14 Supply paranoia
    Added placeholder filter networks on supplies to AX5043. Supply lines only went to two vias, so I pulled back the 3V3_Protected zone and made that all ground. Routed supplies to TXCO and AX5043 separ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
2022-08-15 Add designer names
2022-08-15 datasheet links
    added/updated some datasheet links. Verified that all cap values are valid
2022-08-16 Update page size & data Added data sent to OshPark and revision number Updated page size to ISO A4
2022-08-17 Updated bus header
    Modified bus header part number to reflect that we are now using a straight header versus a passthrough header. Selected part for correct pin length (or at least the best we can get in stock)
2022-08-18 Added DNP field for HTML BOM
    Added a "DNP" field for the HTML BOM. You can tell the HTML BOM to ignore all parts with a non-empty field (in this case, the DNP field).
2022-08-19 Verified orderable part numbers for active parts
    Verified orderable part numbers for active parts
2022-08-19 Update SilverSat_Comms.kicad_pcb
    Forgot to save pcb too
2022-08-19 Generated new BOM spreadsheets
    Really recommend using the HTML BOM, but these are close. Make sure to scroll down for the consolidated info in the csv file. The xml file is harder to interpret.
2022-08-20 Update file list
2022-08-20 Extend previous issue description
2022-08-21 Revert "Merge branch 'main' of https://github.com/silver-sat/Radio_Board"
    This reverts commit 7715a74c3cad480ad7efa51a2105dc50408c0510, reversing
    changes made to 14f71d9b3ba0e7463b928ba6e0593949c367e08c.
2022-08-21 Added some thermal references
    See commit message
2022-08-22 Reflect last repo. commit
2022-08-22 Add PNG
    Add PNG version of SilverSat_Comms-User_Drawings.svg
2022-08-23 Delete Radio_Board.blend1
    File seems unnecessary
2022-08-24 Update description
2022-08-24 Remove unused whitespace from trade images
2022-08-24 Add diagram Inkscape source files
2022-08-24 Add back board view
2022-08-24 Rearrangements and typing fixes
2022-08-24 Update board reference date
2022-08-24 Update associated PNG
2022-08-24 Add power amplifier trade
2022-08-26 Add draft test directions
2022-08-26 Add H1 & H2 pinout
2022-08-27 Add slides from 2022-08-27 meeting
2022-10-08 Test instruction fix 1 of 2022-10-08
2022-10-10 Add back photo + Front photo adjustments
2022-10-10 Create AMSAT-IARU_Link_Model_Rev2.5.5.xls
    Adding in a draft of a filled out version of the AMSAT-IARU spreadsheet
2022-10-18 Test document exercise
    Start of documentation for test plans. Document to be presented to team to get started on developing formal test plan for entire board.
2022-10-24 Moved test docs from root into folder
    Moved my eFuse test docs into the Test Plans folder.
2022-11-06 Create TPS2594x-Calculation Sheet V1p0 (version 1).xlsx
    This is the design backup for the 5V eFuse
2022-11-27 Update README cover image
2022-11-27 Remove unnecessary CGI board image
2023-02-24 Conciseness in board description
    TODO: Possible expansion.
    Contributors: If there is any information you feel is missing from this, send me an email about it.
2023-09-19 Board photographs
2023-12-12 Add MATLAb autosave to .gitignore
2023-12-13 spectrum photos
    adding spectrum photos
2024-02-27 Shift Radio_SCK and Radio_SDA pins right
2024-02-27 Add KiCad 7 file locks to .gitignore
2024-03-16 Update to KiCad 8
2024-03-17 Fixed H2 pinout
    Changed H2 pinout to match new definition. Updated PCB to match. No copper changes to PCB, just nets.
2024-03-23 Add spacers
2024-04-06 Add fiducials
2024-04-20 Replace radio board outline with Avionics outlinl
2024-04-20 Update U4 hole size
    The via hole size in U6 was too small for OshPark. The diameter was changed from 0.2000 mm to 0.2540 mm. There are now annular width errors, but the margin is now four micrometers which is insignific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
2024-04-22 Move power and ground zones away from board edges
2024-04-27 Set DNI parts as DNP: Master BOM parity check 0
2024-04-27 Parity error fix 0
    There was a parity error on ATSAMD21G18-A. The Master BOM lists *-AF, but SilverSat has already ordered *.MF.
2024-05-04 Update 3D models
2024-05-14 Remove tracks within U3 ground pad
2024-05-18 Revert nickel-silver RF shields to stainless steel
2024-05-18 Change C1 part number
2024-05-31 Change attenuator to 7 dB; update resistor detasheet links
2024-06-01 Move J1 away from the board edge
2024-06-01 LF to CRLF change
