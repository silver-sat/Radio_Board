# Repository silver-sat/Radio_Board

File README.md:

# Radio_Board
SilverSat Limited – https://silversat.org

Radio board front view

**SilverSat is currently transistioning the repository to KiCad 8.0. These
updated files are incompatible with older versions.**

SilverSat's Radio Board is our custom-designed Arduino®-compatible prototype
satellite data transceiver and internet gateway for 430-450 MHz.

This repository contains the board design in KiCad 6.0 with relevant design
files and images.

# Setup
1. If you haven't already done so, download and install KiCad 6.0 from their
website, https://www.kicad.org/download/. Depending on your system and Internet
connection, than may take several hours.
2. On the top right of the repsitory's main page, click “Code” to select
download options. On all operating systems, you can download and extract a ZIP
archive to your perrfered folder. Alternatively, you can use one of the many
free Git access programs available from the Internet. Here are instructions for
a few common programs.
   * On Windows and Mac, you can download and install GitHub Desktop
   (https://desktop.github.com/) to access and manage Git repositories. See
   https://docs.github.com/en/desktop/contributing-and-collaborating-using-github-desktop/adding-and-cloning-repositories/cloning-a-repository-from-github-to-github-desktop for details.
   * There are also many command line interfaces available. For example, GitHub
    offers `gh` which can be downloaded from their repository
    (https://github.com/cli/cli). Once you install the client, navigate to your
    perferred folder and run the command given by our repository's Code tab.
   * On Unix and Linux, many software repositories offer `git` as an
   alternative to `gh`. You can download and install `git` from your package
   manager.
     - Debian-based Linux: `sudo apt install git`
     - RedHat Linux or derivatives: `sudo yum install git`
     - macOS (using [Homebrew](https://github.com/Homebrew/brew)):
     `brew install git`
   * For other programs, see their associated documentation for directions.
3. Download and install SilverSat's KiCad Library
(https://github.com/silver-sat/kicad_library). Installation instructions are
given on the library's README.md.
   - It is possible to skip this step, but some parts (such as the TCXO) may
   fail to load.¹
5. Enter the project folder and open SilverSat_Comms.kicad_pro. KiCad will show
 options to edit the schematic or PCB.

# Software
See SilverSat's Radio Software repository
(https://github.com/silver-sat/Radio_Software)

## Known Issues
- KiCad 6, required by our project, is not supported on Windows 7 or earlier
releases. We have not yet tested Windows 8.
- It is possible that Windows users of KiCad versions 6.0.0 to 6.0.4 may
experience issues with sudden component changes using using the Edit Schematic
Fields tool.
- When adding, removing, or moving components in the schematic, importing the
changes into the PCB may cause components to change places. Although they can
be moved back in place, it is easier to preserve annotations (or, if you add a
component, manually annnotate it).
- Due to the large size of this repository, it may download slowly depending on
your connection speed. On a 5 Mb/s connection, this time is approximately 13
minutes. To reduce download time, clone in headless mode `(git clone ... -d 1
...)`

# Warnings
This board was designed for the
[OshPark 4-Layer PCB Service](https://docs.oshpark.com/services/four-layer/).
Using another board type or service will require adjustments to the RF
amplifier lines and may require other appropriate compensations.

# Notes
¹ We have not yet tested whether this will work, but we presume based on past
experience that the resulting error can be ignored.

## KiCad design SilverSat_Comms.kicad_pcb

Parts:
C1: 0.01u; C_0603_1608Metric; Voltage 100V/18kV; MPN KAE15AR72A103KT18
F1: 300 mA; Fuse_0805_2012Metric; Part_Number PICOASMDC012S-2
FID1, FID2, FID3: Fiducial; Fiducial_1.5mm_Mask2.5mm
H1, H2: Conn_02x26_Odd_Even; TheBus2x26; Part_Number HMTSW-126-22-G-D-440
H3, H4, H5, H6: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_TopBottom
H7, H8, H9, H10: MountingHole_Pad; MountingHole_2.2mm_M2_DIN965_Pad_TopBottom
J1: USB_B_Micro; USB_Micro-B_Molex-105017-0001; Part_Number 105017-0001
J2: Conn_Coaxial; SMA_Amphenol_901-143_Horizontal; MPN 901-143-6RFX; Mouser Part Number 523-901-143-6RFX
J3: 53261-0471; Molex_PicoBlade_53261-0471_1x04-1MP_P1.25mm_Horizontal; MPN 53261-0471
J4: 504050-0691; Molex_Pico-Lock_504050-0691_1x06-1MP_P1.50mm_Horizontal; MPN 504050-0691
J8, J9: ESQ-126-69-G-D; MPN ESQ-126-69-G-D
R1: 1M; R_0603_1608Metric; MPN ERJ-PA3F1004V
R2, R3, R4, R5, R41, R42, R43: 0; R_0402_1005Metric; MPN ERJ-2GE0R00X; Mouser Part Number 667-ERJ-H2G0R00X
TP5: 5V; TestPoint_Pad_D1.0mm
TP6: 3V3; TestPoint_Pad_D1.0mm
TP7: USB_D+; TestPoint_Pad_D1.0mm
TP8: USB_D-; TestPoint_Pad_D1.0mm
U1: USBLC6-2SC6; SOT-23-6; MPN USBLC6-4SC6

Connections:
+3V3: H2.27, H2.28, TP6.1; also elsewhere on the board
+5V: H2.25, H2.26, J4.6, TP5.1; also elsewhere on the board
+5VP: F1.2, U1.5 (VBUS)
/3V3_Protected: R41.2; also elsewhere on the board
/+3V3_LUP: H1.48
/+5V_LUP: H1.51
/BCR_Out: H2.41, H2.42, H2.43, H2.44
/BattRaw: H2.45, H2.46
/EPS_0: H2.12
/EPS_1: H2.14
/EPS_5V_USB: H1.32
/EPS_RESET: H1.28
/Out1 (EPS): H2.3
/Out2 (EPS): H2.4
/Out3 (EPS): H2.5
/Out4 (EPS): H2.6
/Out5 (EPS): H2.7
/Out6 (EPS): H2.8
/PAPowerSwitch/Vin: R42.2; also elsewhere on the board
/PAPowerSwitch/Vout: R43.2; also elsewhere on the board
/PASwitch/5V: R43.1; also elsewhere on the board
/PAYLOAD_OC: H2.17
/PAYLOAD_ON_A: H2.16
/PAYLOAD_ON_B: H2.18
/PAYLOAD_ON_C: H2.20
/PAYLOAD_RXD+: H1.5; also elsewhere on the board
/PAYLOAD_RXD-: H1.7; also elsewhere on the board
/PAYLOAD_TXD+: H1.6; also elsewhere on the board
/PAYLOAD_TXD-: H1.8; also elsewhere on the board
/PLD_SCLK: H1.47
/PLD_SDA: H1.45
/Power_SCLK: H1.43
/Power_SDA: H1.41
/RADIO_RXD+: H1.10; also elsewhere on the board
/RADIO_RXD-: H1.12; also elsewhere on the board
/RADIO_TXD+: H1.9; also elsewhere on the board
/RADIO_TXD-: H1.11; also elsewhere on the board
/RF: J2.1 (In); also elsewhere on the board
/RS485_A: H1.24
/RS485_B: H1.22
/Radio_SCLK: H1.39, J4.5
/Radio_SDA: H1.37, J4.4
/Release_A: J4.2; also elsewhere on the board
/Release_B: J4.1; also elsewhere on the board
/SHUTDOWN_A: H2.9
/SHUTDOWN_B: H2.11
/SHUTDOWN_C: H2.13
/STATES_A: H2.10
/STATES_B: H2.22
/STATES_C: H2.24
/USB_D+: J1.3 (D+), J3.2, TP7.1, U1.1 (I/O1), U1.6 (I/O1); also elsewhere on the board
/USB_D-: J1.2 (D-), J3.3, TP8.1, U1.3 (I/O2), U1.4 (I/O2); also elsewhere on the board
/V_RTC: H1.30
/eFuse3V3.sch/3V3_P: R41.1; also elsewhere on the board
/eFuse5V/5V_LUP: R42.1; also elsewhere on the board
/~RESET: J3.1; also elsewhere on the board
GND: C1.2, H1.3, H1.13, H1.38, H1.42, H1.46, H1.50, H2.15, H2.29, H2.30, H2.31, H2.32, H7.1, H8.1, H9.1, H10.1, J1.5 (GND), J2.2 (Ext), J3.4, J3.MP (MountPin), J4.3, J4.MP, R1.2, R2.2, R3.2, R4.2, R5.2, U1.2 (GND); also elsewhere on the board
unnamed: H3.1, R2.1
unnamed: H4.1, R3.1
unnamed: H5.1, R4.1
unnamed: H6.1, R5.1
unnamed: C1.1, J1.6 (Shield), R1.1
unnamed: F1.1, J1.1 (VBUS)

Notes on the sheet:
SCIC
+5VP is the power from the USB bus
Board Mounting Holes
A 0Ω resistor can be installed to ground the holes
Antenna Interface
See Figure 15 in AX5043 Datasheet
iq = 1.1mA
bring PWRAMP out to test header, but can be removed if needed for space
imax ~ 48mA(TBD)
See FP2004 datasheet (and test results): OC3V3 is active LOW Probably don't care because result is not latched. OC5V is also active low
place close to PA
Avionics Interface Note: Avionics did not cross, so we have to cross is done after driver, at H1
Heat Spreader Mount
Need to add a V to 3.3V Regulator here Connect VBUS to EPS? Need to rethink what will be done using USB power ...USB may not source enough for PA. USB is used to talk to SAMD21, and possibly (if not using SWD) reprogram the SAMD21. 5V is NOT used to power the PA. PA 5V supply must be supplied exter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
We're never going to be a host, so just leave ID floating
For Pullup
For next revision: Bring out TxD2/RxD2, TxD1/RxD1, TxD0/RxD0 on separate headers. Make them compatible with FTDI USB cables. Make sure there's an easy way to tristate the serial drivers. Note that the SAMD21 is not 5V tolerant, so it might be good to add buffers to protect the part. Also note that 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
Payload interface Note: Payload did cross, so we don't
EPS_5V_USB does not exist on EPS
Serial port net names are the same as used by Avionics.
Consider TL1963A for LDO if we want to power SAMD21 via USB. It has reverse current and voltage protection. (i.e. its output can be directly connected to +3.3V)
imax ~ 20mA(TBD)?

Parts:
C2, C3: 20p; C_0603_1608Metric; MPN 06031A200K4T2A
C4, C6, C8, C9, C10, C12: 0.1u; C_0603_1608Metric; MPN 06031C104K4Z2A
C5, C7, C13: 1u; C_0805_2012Metric; Part_Number 12065C105M4Z2A; Mouser Part Number 581-08053C105K4Z2A
C11: 4.7u; C_0603_1608Metric; MPN GRT188C81C475KE13D
D1: LED; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
J5: MTSW-103-06-G-D-110; PinHeader_2x03_P2.54mm_Vertical; MPN MTSW-103-06-G-D-110
J6: 77311-118-02LF; PinHeader_1x02_P2.54mm_Vertical; MPN 77311-118-02LF
J7: PinHeader_2x05_P1.27mm_Vertical_SMD; Part_Number 4048
L1: Ferrite Bead; L_0603_1608Metric; Part_Number BLM18SP102SH1D
R6, R7, R8, R9, R12, R13: 10k; R_0603_1608Metric; MPN ERJ-3RBD1002V
R10: 931; R_0603_1608Metric; Part_Number ERJ-3EKF9310V
R11: 330; R_0603_1608Metric; MPN ERJ-H3EF3300V
TP1: AREF; TestPoint_Pad_D1.0mm
U2: ATSAMD21G18A-A; TQFP-48_7x7mm_P0.5mm; MPN ATSAMD21G18A-AF
Y1: CM8V-T1A-32.768KHZ-12.5PF-20PPM-TB-QA; Crystal_SMD_MicroCrystal_CC8V-T1A-2Pin_2.0x1.2mm; Manufacturer_Part_Number CM8V-T1A-32.768KHZ-12.5PF-20PPM-TB-QA

Connections:
/3V3_Protected: C8.1, C10.1, C12.1, C13.2, J5.2, J7.1, L1.1, R6.1, R7.1, R8.1, R9.1, R12.1, R13.1, U2.17 (VDDIO), U2.36 (VDDIO), U2.44 (VDDIN); also elsewhere on the board
/5V_Current: U2.8 (PB09); also elsewhere on the board
/DATA: U2.24 (PA15); also elsewhere on the board
/DCLK: U2.22 (PA13); also elsewhere on the board
/EN0: U2.28 (PA19); also elsewhere on the board
/EN1: U2.27 (PA18); also elsewhere on the board
/ExternalWatchdog/WDTICK: U2.38 (PB23); also elsewhere on the board
/IRQ: U2.9 (PA04); also elsewhere on the board
/MISO: J5.1, U2.21 (PA12); also elsewhere on the board
/MOSI: J5.4, U2.19 (PB10); also elsewhere on the board
/OC5V: U2.12 (PA07); also elsewhere on the board
/PAENABLE: U2.47 (PB02); also elsewhere on the board
/RXD0: U2.16 (PA11); also elsewhere on the board
/RXD1: U2.26 (PA17); also elsewhere on the board
/Release_A: U2.7 (PB08); also elsewhere on the board
/Release_B: U2.3 (PA02); also elsewhere on the board
/SAMD21/AREF: C9.1, C11.1, TP1.1, U2.4 (PA03)
/SAMD21/GPIO4: U2.23 (PA14)
/SAMD21/GPIO14: U2.29 (PA20)
/SAMD21/GPIO15: U2.30 (PA21)
/SAMD21/RX_LED_SWDIO: J7.2, U2.46 (PA31)
/SAMD21/SCL1: R6.2, U2.14 (PA09)
/SAMD21/SDA1: R8.2, U2.13 (PA08)
/SAMD21/SWCLK: J7.4, R13.2, U2.45 (PA30)
/SAMD21/TXLED: R10.2, U2.39 (PA27)
/SAMD21/X1: C3.2, U2.1 (PA00), Y1.2
/SAMD21/X2: C2.2, U2.2 (PA01), Y1.1
/SCK: J5.3, U2.20 (PB11); also elsewhere on the board
/SCL: R7.2, U2.32 (PA23); also elsewhere on the board
/SDA: R9.2, U2.31 (PA22); also elsewhere on the board
/SYSCLK: U2.11 (PA06); also elsewhere on the board
/TXD0: U2.15 (PA10); also elsewhere on the board
/TXD1: U2.25 (PA16); also elsewhere on the board
/TX/~RX: U2.37 (PB22); also elsewhere on the board
/USB_D+: U2.34 (PA25); also elsewhere on the board
/USB_D-: U2.33 (PA24); also elsewhere on the board
/~RESET: J5.5, J6.2, J7.10, R11.2; also elsewhere on the board
/~SEL: U2.10 (PA05); also elsewhere on the board
/~TX/RX: U2.48 (PB03); also elsewhere on the board
GND: C2.1, C3.1, C4.2, C5.2, C6.2, C7.1, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, D1.1 (K), J5.6, J6.1, J7.3, J7.5, U2.5 (GNDANA), U2.18 (GND), U2.35 (GND), U2.42 (GND); also elsewhere on the board
unnamed: D1.2 (A), R10.1
unnamed: C6.1, C7.2, L1.2, U2.6 (VDDANA)
unnamed: C5.1, U2.43 (VDDCORE)
unnamed: C4.1, R11.1, R12.2, U2.40 (~RESET)

Notes on the sheet:
PA23
Add 32.768KHz crystal and caps (in case we want to use as timer) See SAMD21 datasheet for crystal specs page 972
i2c pullups need to be adjusted depending on load
PA22
SERCOM 3.0
See SAMD21 datasheet page 1,080 for connections
SERCOM-ALT 2.2
SERCOM-ALT 5.0
SERCOM 5.3
SERCOM-ALT 5.1
Reassigned Metro Pins Name SDA SCL D1 D0 MOSI SCK D6 D7 D11 D13 D12 D4 D3 D21/SCL FLASH_MOSI MISO
Just in case: Only Serial1 can have RTS/CTS defined (needs TX defined on pad 0) But that's going to Avionics...
SERCOM-ALT 2.3
X1 and X2 net area are 0.00494 sq in. as measured using Altium Gerber viewer Layer thickness is 0.00796 in per stackup, dielectric const. = 3.69 Estimated capacitance (added to input/output) about 0.5p each Assuming Cstray about 0.5p, CLEXT should be about 20pF each, depending on Cstray
SERCOM 0.1
SERCOM 5.2
SERCOM 0.3
GPIO
Supply Bypass
SERCOM 0.2
SERCOM-ALT 3.0
CXIN = 3.1p CXOUT = 3.3p CSTRAY = 0.5p (for now) CLOAD = 12.5p
From SAMD21 datasheet: CLOAD = ([CXIN + CLEXT] * [CXOUT + CLEXT]) / ([CXIN + CLEXT + CLEXT + CXOUT]) + CSTRAY
C8 goes to R7 and R9
SERCOM 3.1
Using Murata 0603 Automotive part. In next rev, we might want to consolidate all 4.7u
SWD Header
SERCOM 0.0
SERCOM-ALT 3.2
new function SDA0 SCL0 TXD0 RXD0 MOSI (on 6 pin header) SCK (on 6 pin header) TXD2 RXD2 TXD1 RXD1 GPIO8 SDA1 SCL1 WDTICK GPIO11 MISO (on 6 pin header)
ICSP Header
Release_B Release_A 5V_Current TX/~{RX} ~{TX}/RX PAENABLE ENO EN1 DCLK DATA OC3V3 OC5V SYSCLK ~{SEL} IRQ
SERCOM-ALT 3.1
SIGNAL
In code: Serial0 is TXD1/RXD1 Serial1 is TXD0/RXD0 Serial2 is unused as a stand-in for the radio in testing Mapping is a result of variant definition.
14_A 13 12 11 10 9 8 7 6 5 4 3 2 1 0
PA21
Analog Reference Voltage Bypass
Translation table from GPIOx to Metro Pin port | pin | Metro GPIO14_A | PA02 | A0 GPIO0 | PA04 | A3 GPIO1 | PA05 | A4 GPIO2 | PA06 | D8 GPIO3 | PA07 | D9 GPIO4 | PA14 | D2 GPIO5 | PA15 | D5 GPIO6 | PA13 | FLASH_CS GPIO7 | PA18 | D10 GPIO8 | PA19 | D12 GPIO9 | PB02 | A5 GPIO10 | PB03 | FLASH_MISO GP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
SERCOM-ALT 2.0

Parts:
C14, C17, C18, C68: 0.01u; C_0603_1608Metric; Manufacturer_Part_Number 06033C103J4Z2A; Mouser Part Number 581-06033C103J4Z2A
C15: 39p; C_0402_1005Metric; MPN GRT1555C1H390FA02D; Mouser Part Number 581-06035A390J4T2A
C16, C24, C25, C26, C35, C37, C69, C70: DNI; C_0402_1005Metric; not fitted
C19: 4.7u; C_0603_1608Metric; MPN GRT188C81C475KE13D; Mouser Part Number 581-12065C475K4Z2A
C20, C21: 100p; C_0402_1005Metric; MPN GCM1555C1H101FA16J; Mouser Part Number -- mixed values --
C22: 0.1u; C_0603_1608Metric; MPN 06031C104K4Z2A
C23: 0.01u; C_0603_1608Metric; MPN 06033C103J4Z2A
C27, C28, C29: 4.3p; C_0402_1005Metric; MPN GCM1555C1H4R3BA16D; Mouser Part Number 581-04023A4R7B4T2A
C30, C31, C32: 5.6p; C_0402_1005Metric; MPN 04025U5R6B4T2A; Mouser Part Number 581-04025U5R6B4T2A
C33, C34: 5.1p; C_0402_1005Metric; MPN GCQ1555C1H5R1WB01D; Mouser Part Number 81-GCQ1555C1H5R1WB01D
C36: 6.8p; C_0402_1005Metric; MPN GCM1555C1H6R8BA16D; Mouser Part Number 581-04025U6R8B4T2A
C38, C67: 100p; C_0402_1005Metric; MPN GCM1555C1H101FA16J; Mouser Part Number 581-04025A101K4T2A
L2: 10n; L_0603_1608Metric; MPN 0603DC-10NXJRW; Mouser Part Number 994-0603DC-10NXJRW
L3, L4, L5: 0.100u; Coilcraft_L_0402_1005Metric; MPN 0402DC-R10XJRW; Mouser Part Number 994-0402DC-R10XJRW
L6, L7, L8: 43n; Coilcraft_L_0402_1005Metric; MPN 0402DC-43NXGRW; Mouser Part Number 994-0402DC-43NXGRW
L9, L10: 27n; Coilcraft_L_0402_1005Metric; MPN 0402DC-27NXGRW; Mouser Part Number 994-0402DC-27NXGRW
L11: 4.7n; Coilcraft_L_0402_1005Metric; MPN 0402DC-4N7XGRW; Mouser Part Number 994-0402DC-4N7XGRW
R14, R44, R45: 0; R_0402_1005Metric; MPN ERJ-2GE0R00X; Mouser Part Number 667-ERJ-H2G0R00X
R15: 12k; R_0603_1608Metric; MPN ERJ-3RBD123V; Mouser Part Number 667-ERJ-PB3B1202V
R16: 220; R_0603_1608Metric; MPN ERJ-PB3D2200V
R17: 100; R_0603_1608Metric; MPN ERJ-3RBD101V; Mouser Part Number 667-ERJ-H3ED1000V
S1: MS355-10F_Masach_Shield; MS355-10_Masach_Shield; MPN MS355-10F; not fitted
S2: MS355-10C_Masach_Shield_Cover; MPN MS355-10C; not fitted
TP2, TP3, TP4: TestPoint; TestPoint_Pad_D1.0mm
U3: AX5043; QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm; Mouser Part Number 863-AX5043-1-TW30
X1: TG2016SMN; Crystal_SMD_2016-4Pin_2.0x1.6mm; Voltage 3.3; MPN TG2016SMN 48.0000M-MCGNNM3

Connections:
/3V3_Protected: R44.1, R45.1; also elsewhere on the board
/AX5043/Attenuator/RX: C67.1; also elsewhere on the board
/AX5043/Attenuator/VOUT: C36.2, C37.1, L11.2; also elsewhere on the board
/DATA: TP3.1, U3.11 (DATA); also elsewhere on the board
/DCLK: TP4.1, U3.12 (DCLK); also elsewhere on the board
/IRQ: U3.19 (IRQ); also elsewhere on the board
/MISO: U3.16 (MISO); also elsewhere on the board
/MOSI: U3.17 (MOSI); also elsewhere on the board
/PA: C67.2; also elsewhere on the board
/PWRAMP: C22.1, R17.2, TP2.1
/RX: C38.2; also elsewhere on the board
/SCK: U3.15 (CLK); also elsewhere on the board
/SYSCLK: U3.13 (SYSCLK); also elsewhere on the board
/~SEL: U3.14 (SEL); also elsewhere on the board
GND: C14.2, C15.2, C16.1, C17.2, C19.1, C20.2, C21.2, C22.2, C23.1, C24.1, C25.1, C26.2, C30.1, C31.2, C32.2, C33.2, C35.2, C37.2, C68.1, C69.1, C70.1, L3.1, L4.1, L5.2, L9.2, R14.1, S1.1 (SHIELD), S2.1, U3.2 (GND), U3.6 (GND), U3.25 (GPADC1), U3.26 (GPADC2), U3.29 (GND), X1.2 (GND); also elsewhere on the board
unnamed: C14.1, R15.1
unnamed: C20.1, U3.1 (VDD_ANA)
unnamed: C21.1, U3.7 (VDD_ANA)
unnamed: C27.2, L8.2
unnamed: C28.2, L6.1
unnamed: C29.1, L7.1
unnamed: C30.2, C33.1, L6.2, L10.1
unnamed: C31.1, C34.2, L7.2, L9.1
unnamed: C32.1, C35.1, C36.1, L8.1, L11.1
unnamed: C34.1, C38.1, L10.2
unnamed: C25.2, C28.1, L4.2, U3.4 (ANTN)
unnamed: C24.2, C27.1, L3.2, U3.5 (ANTP1)
unnamed: C26.1, C29.2, L5.1, U3.3 (ANTP)
unnamed: C23.2, R16.2, U3.27 (CLK16N)
unnamed: C16.2, C18.2, R16.1, U3.28 (CLK16P)
unnamed: C15.1, R15.2, U3.8 (FILT)
unnamed: L2.2, U3.10 (L1)
unnamed: L2.1, U3.9 (L2)
unnamed: R17.1, U3.20 (PWRAMP)
unnamed: C19.2, C68.2, C70.2, R45.2, U3.23 (VDD_IO)
unnamed: C18.1, X1.3 (OUT)
unnamed: R14.2, X1.1 (VC)
unnamed: C17.1, C69.2, R44.2, X1.4 (VDD)

Notes on the sheet:
Note: ANTN and ANTP reversed relative to reference
Removed line from GPADC1 to FILT (was for cal of xtal) Grounded GPADC1 and GPADC2 per datasheet
Harmonic Filter
Class E amplifier networks
Lumped element BALUN

Parts:
C48: 12p; C_0402_1005Metric; MPN 04025A120F4T2A
C49: 15p; C_0402_1005Metric; MPN GRT1555C1H150FA02D
C50: 2.2u; C_1210_3225Metric; MPN C1210C225K1RACAUTO
C51: 100p; C_0402_1005Metric; MPN GCM1555C1H101FA16J
C52, C53: 6.8p; C_0402_1005Metric; MPN GCM1555C1H6R8BA16D
C54: 39p; C_0402_1005Metric; MPN GRT1555C1H390FA02D
C55, C56: 56p; C_0402_1005Metric; MPN GCM1555C1H560FA16D
C57, C58: 220p; C_0402_1005Metric; MPN GRT1555C1H221FA02D
L13: 39n; Coilcraft_L_0402_1005Metric; MPN 0402DC-39NXGRW
L14: 4.3n; Coilcraft_L_0402_1005Metric; MPN 0402DC-4N3XGRW
L15: 47n; Coilcraft_L_0402_1005Metric; MPN 0402DC-47NXGRW
L16: 5.1n; Coilcraft_L_0402_1005Metric; MPN 0402DC-5N1XGRW
PA1: HMC452ST89; MPN HMC452ST89
R30: 5.1; R_0603_1608Metric; MPN ERJ-U03F5R10V
R31, R32: 0; R_0402_1005Metric; MPN ERJ-2GE0R00X; Mouser Part Number 667-ERJ-H2G0R00X
S3: MS355-10F_Masach_Shield; MS355-10_Masach_Shield; MPN MS355-10F; not fitted
S4: MS355-10C_Masach_Shield_Cover; SilverSat_logo_15x7.75mm; MPN MS355-10C; not fitted
U7: CG2409M2-C4; SOT-363_SC-70-6; MPN CG2409M2-C4

Connections:
/PA: C48.2, L13.1; also elsewhere on the board
/PASwitch/5V: C50.1, C51.2, L15.1; also elsewhere on the board
/RF: C56.2; also elsewhere on the board
/RX: C55.1; also elsewhere on the board
/TX/~RX: R31.2; also elsewhere on the board
/~TX/RX: R32.2; also elsewhere on the board
GND: C49.2, C50.2, C52.2, C53.2, C57.1, C58.2, L13.2, PA1.2 (GND), R30.2, S3.1 (SHIELD), S4.1, U7.2 (GND); also elsewhere on the board
unnamed: C48.1, C49.1, L14.1
unnamed: C51.1, R30.1
unnamed: C52.1, C53.1, C54.2, L16.2
unnamed: L14.2, PA1.1 (RFIN)
unnamed: L15.2, L16.1, PA1.3 (RFOUT)
unnamed: C56.1, U7.5 (J1)
unnamed: C55.2, U7.3 (J2)
unnamed: C54.1, U7.1 (J3)
unnamed: C58.1, R31.1, U7.6 (V1)
unnamed: C57.2, R32.1, U7.4 (V2)

Notes on the sheet:
TL5
NOTE: Since we are driving the PA from the single-ended output of the AX5043, the maximum output power is +13dBm, not +16dBm. Expected gain of the HMC452 is 21dB (not including matching network losses), so we still should be able to drive the amp into saturation.
NOTE: PA does not like to have an input signal at turn on until it settles at its DC bias point. Damage is highly likely. YOU HAVE BEEN WARNED!!
TL4
TL1
TL2
RF2
RF_OUT
TL3
RF1

Parts:
U8: TMP100; SOT-23-6; MPN TMP100NA/3K

Connections:
/3V3_Protected: U8.4 (V+); also elsewhere on the board
/SCL: U8.1 (SCL); also elsewhere on the board
/SDA: U8.6 (SDA); also elsewhere on the board
GND: U8.2 (GND), U8.5 (ADD0); also elsewhere on the board

Notes on the sheet:
setting address for 0x49 leaving add1 floating allows for address change if needed
need bypass

Notices in the files:
Arduino_Board_Definitions/SilverSat_Radio_Board/0.1/variants/mkrwifi1010/variant.cpp:
Copyright (c) SilverSat Limited (https://silversat.org)
This file has been modified from the Arduino MKR WiFi 1010 board definition,
copyrighted 2014-15 Arduino LLC under the LGPL. It was originally modified
